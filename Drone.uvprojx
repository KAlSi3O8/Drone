# Keil uVision project Drone.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Drone +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F401xE
  c include: .\User;.\Drivers;.\Lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./User/: main.c anotc.c Madgwick.c my_math.c
  group LIB
    ./Lib/: MyI2C.c MyUART.c MyTIM.c zimo.c
  group DRIVERS
    ./Drivers/: OLED.c GY-86.c Motor.c ESP8266.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
